# Keil uVision project counter.uvproj, settings and files
target Counter (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: show_raw_value +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: SizeSpeed=1
  c define: CLOCK=4000000
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\inc
  group Source
    ../src/: htim.c main.c vcnl4040.c usr_i2c.c
  group Library
    ../Library/StdDriver/src/: common.c sys.c
  group Startup
    ../Library/Startup/Keil/: STARTUP.A51
